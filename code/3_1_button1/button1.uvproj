# Keil uVision project button1.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5202AD Series STC
  cpu: IRAM(0-0xFF) IROM(0-0x7FF) CLOCK(45000000)
  output: button1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c
